		EXPORT  __main			
tam		EQU		5	
		AREA	M_DADOS, DATA, READWRITE
			
vtg		SPACE	tam		
vth		SPACE	tam
	
		AREA	M_PROGRAMA, CODE, READONLY
__main
		LDR		R0,=vtg
		LDR		R8,=vth
		MOV		R10,#0
		MOV		R2,#2_00100101 	;MASCARA
		MOV		R3,#2_11011010	;CONTRA-MASCARA
		MOV		R4,#2_11111111	;MASCARA XOR
		MOV		R9,#tam			;CONTADOR DO LOOP		
LOOP	LDRB	R1,[R0],#1		;VALOR DE R0 PARA R1
		AND		R5,R1,R2		;APLICA MаSCARA EM R1 E SALVA EM R5
		ORR		R6,R5,R3		;APLICA CONTRA MASCARA EM R5 E SALVA EM R6
		EORS	R7,R6,R4		;XOR EM R6 SALVANDO EM R7 E ATUALIZANDO OS FLAGS
		BEQ		GUARDAH			;SE O RESULTADO FOR TUDO 0, FLAG Z IRA ATUALIZAR E SEGUIRA A BRANCH
		STRB	R10,[R8], #1	;CASO CONTRARIO, SALVA VALOR 0 EM H
		SUBS	R9,#1			;DESCRECIMO NO CONTADOR
		BNE		LOOP			;CRITEIRO DE PARADA
		B		__main
GUARDAH
		STRB	R1,[R8],#1		;GUARDA VALOR DE R1 EM R8 (H)
		SUBS	R9,#1			;DESCRECIMO NO CONTADOR
		BNE		LOOP			;CRITEIRO DE PARADA
		B		__main
		END