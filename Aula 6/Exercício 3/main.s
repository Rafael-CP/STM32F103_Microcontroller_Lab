		EXPORT  __main
			
tam		EQU		2	
	
		AREA	M_DADOS, DATA, READWRITE
			
vtk		SPACE	tam		
	
		AREA	M_PROGRAMA, CODE, READONLY
__main
		LDR		R0,=vtk
		MOV		R2,#0	;CONTADOR DE 0
		MOV		R5,#1	
		MOV		R7,#tam	;CONTADOR DO LOOP EXTERNO
LOOPEXT		
		LDRB	R1,[R0]
		MOV		R3,#8	;CONTADOR LOOP INTERNO
LOOPINT	
		LSRS	R4,R1,R5
		BCC		SOMA	;EXECUTA SE BIT FOR 0
VOLTA   	SUBS	R3,#1
		ADD		R5,#1
		BNE		LOOPINT	;EXECUTA SE R3 != 0
		ADD		R0,#1
		MOV		R5,#1
		SUBS	R7,#1
		BNE		LOOPEXT	;EXECUTA SE R7 != 0
		B		__main
		
SOMA	ADD		R2,#1	
		B		VOLTA

		END